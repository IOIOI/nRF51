# IAR project ant_background_scanning_s210_n5_starterkit.ewp, settings and files
configuration nrf51422_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxaa nRF51422_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ANT_STACK_SUPPORT_REQD; ENABLE_DEBUG_LOG_SUPPORT; S210; BOARD_N5DK1; NRF51; SOFTDEVICE_PRESENT; SWI_DISABLE0; NRF_LOG_USES_UART=1
  ICCARM.CCIncludePath2: ..\..\config\ant_background_scanning_s210_n5_starterkit; ..\..\config; ..\..\..\..\..\components\ant\ant_channel_config; ..\..\..\..\..\components\ant\ant_search_config; ..\..\..\..\..\components\ant\ant_stack_config; ..\..\..\..\..\components\device; ..\..\..\..\..\components\drivers_ext\segger_rtt; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\components\libraries\button; ..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\components\softdevice\s210\headers; ..\..\..\..\..\components\toolchain; ..\..\..\..\bsp; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\config\ant_background_scanning_s210_n5_starterkit; ..\..\config; ..\..\..\..\..\components\ant\ant_channel_config; ..\..\..\..\..\components\ant\ant_search_config; ..\..\..\..\..\components\ant\ant_stack_config; ..\..\..\..\..\components\device; ..\..\..\..\..\components\drivers_ext\segger_rtt; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\components\libraries\button; ..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\components\softdevice\s210\headers; ..\..\..\..\..\components\toolchain; ..\..\..\..\bsp
  OBJCOPY.OOCOutputFile: ant_background_scanning_s210_n5_starterkit.hex
  ILINK.IlinkOutputFile: ant_background_scanning_s210_n5_starterkit.out
  ILINK.IlinkIcfFile: ant_background_scanning_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../components/drivers_ext/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c nrf_assert.c nrf_log.c
    ../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../components/libraries/timer/: app_timer.c
    ../../../../../components/libraries/trace/: app_trace.c
    ../../../../../components/libraries/uart/: retarget.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_ANT
    ../../../../../components/ant/ant_channel_config/: ant_channel_config.c
    ../../../../../components/ant/ant_search_config/: ant_search_config.c
    ../../../../../components/ant/ant_stack_config/: ant_stack_config.c
  group Board Support
    ../../../../bsp/: bsp.c
  group Application
    ../../: main.c
  group Device
    ../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
  group nRF_SoftDevice
    ../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
