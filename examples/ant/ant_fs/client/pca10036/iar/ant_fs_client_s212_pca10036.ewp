# IAR project ant_fs_client_s212_pca10036.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ANT_STACK_SUPPORT_REQD; TRACE_MEM_WRITE_OFF; LEDDRIVER_ACTIVE; S212; NRF52_PAN_8; NRF52_PAN_9; NRF52_PAN_10; NRF52_PAN_11; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_16; NRF52_PAN_17; NRF52_PAN_20; NRF52_PAN_23; NRF52_PAN_24; NRF52_PAN_25; NRF52_PAN_26; NRF52_PAN_27; NRF52_PAN_28; NRF52_PAN_29; NRF52_PAN_30; NRF52_PAN_32; NRF52_PAN_33; NRF52_PAN_34; NRF52_PAN_35; NRF52_PAN_36; NRF52_PAN_37; NRF52_PAN_38; NRF52_PAN_39; NRF52_PAN_40; NRF52_PAN_41; NRF52_PAN_42; NRF52_PAN_43; NRF52_PAN_44; NRF52_PAN_46; NRF52_PAN_47; NRF52_PAN_48; NRF52_PAN_49; NRF52_PAN_58; NRF52_PAN_63; NRF52_PAN_64; NRF52_PAN_65; CONFIG_GPIO_AS_PINRESET; BOARD_PCA10036; NRF52_PAN_1; NRF52_PAN_2; NRF52_PAN_3; NRF52_PAN_4; NRF52_PAN_7; NRF52; SOFTDEVICE_PRESENT; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\config\ant_fs_client_s212_pca10036; ..\..\config; ..\..\..\..\..\..\components\ant\ant_stack_config; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\ant_fs; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\softdevice\s212\headers; ..\..\..\..\..\..\components\softdevice\s212\headers\nrf52; ..\..\..\..\..\..\components\toolchain; ..\..\include; ..\..\..\..\..\bsp; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\config\ant_fs_client_s212_pca10036; ..\..\config; ..\..\..\..\..\..\components\ant\ant_stack_config; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\ant_fs; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\softdevice\s212\headers; ..\..\..\..\..\..\components\softdevice\s212\headers\nrf52; ..\..\..\..\..\..\components\toolchain; ..\..\include; ..\..\..\..\..\bsp
  OBJCOPY.OOCOutputFile: ant_fs_client_s212_pca10036.hex
  ILINK.IlinkOutputFile: ant_fs_client_s212_pca10036.out
  ILINK.IlinkIcfFile: ant_fs_client_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../components/libraries/ant_fs/: antfs.c crc.c
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/timer/: app_timer.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_ANT
    ../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
  group Board Support
    ../../../../../bsp/: bsp.c
  group Application
    ../../: main.c mem.c retarget.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
