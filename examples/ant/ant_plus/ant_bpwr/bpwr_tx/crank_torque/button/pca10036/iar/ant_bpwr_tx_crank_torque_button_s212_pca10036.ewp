# IAR project ant_bpwr_tx_crank_torque_button_s212_pca10036.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ANT_STACK_SUPPORT_REQD; MODIFICATION_TYPE=0; SENSOR_TYPE=2; ENABLE_DEBUG_LOG_SUPPORT; TRACE_BPWR_GENERAL_ENABLE; TRACE_BPWR_PAGE_1_ENABLE; TRACE_BPWR_PAGE_16_ENABLE; TRACE_BPWR_PAGE_17_ENABLE; TRACE_BPWR_PAGE_18_ENABLE; TRACE_COMMON_PAGE_80_ENABLE; TRACE_COMMON_PAGE_81_ENABLE; S212; NRF52_PAN_8; NRF52_PAN_9; NRF52_PAN_10; NRF52_PAN_11; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_16; NRF52_PAN_17; NRF52_PAN_20; NRF52_PAN_23; NRF52_PAN_24; NRF52_PAN_25; NRF52_PAN_26; NRF52_PAN_27; NRF52_PAN_28; NRF52_PAN_29; NRF52_PAN_30; NRF52_PAN_32; NRF52_PAN_33; NRF52_PAN_34; NRF52_PAN_35; NRF52_PAN_36; NRF52_PAN_37; NRF52_PAN_38; NRF52_PAN_39; NRF52_PAN_40; NRF52_PAN_41; NRF52_PAN_42; NRF52_PAN_43; NRF52_PAN_44; NRF52_PAN_46; NRF52_PAN_47; NRF52_PAN_48; NRF52_PAN_49; NRF52_PAN_58; NRF52_PAN_63; NRF52_PAN_64; NRF52_PAN_65; CONFIG_GPIO_AS_PINRESET; BOARD_PCA10036; NRF52_PAN_1; NRF52_PAN_2; NRF52_PAN_3; NRF52_PAN_4; NRF52_PAN_7; NRF52; SOFTDEVICE_PRESENT; SWI_DISABLE0; NRF_LOG_USES_UART=1
  ICCARM.CCIncludePath2: ..\..\..\..\config\ant_bpwr_tx_crank_torque_button_s212_pca10036; ..\..\..\..\config; ..\..\..\..\..\..\..\..\..\components\ant\ant_channel_config; ..\..\..\..\..\..\..\..\..\components\ant\ant_key_manager; ..\..\..\..\..\..\..\..\..\components\ant\ant_key_manager\config; ..\..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_bpwr; ..\..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_bpwr\pages; ..\..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_bpwr\pages\logger; ..\..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_bpwr\simulator; ..\..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_bpwr\utils; ..\..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_common\pages; ..\..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_common\pages\logger; ..\..\..\..\..\..\..\..\..\components\ant\ant_stack_config; ..\..\..\..\..\..\..\..\..\components\ant\ant_state_indicator; ..\..\..\..\..\..\..\..\..\components\device; ..\..\..\..\..\..\..\..\..\components\drivers_ext\segger_rtt; ..\..\..\..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\..\..\..\components\softdevice\s212\headers; ..\..\..\..\..\..\..\..\..\components\softdevice\s212\headers\nrf52; ..\..\..\..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\..\..\bsp; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\..\..\config\ant_bpwr_tx_crank_torque_button_s212_pca10036; ..\..\..\..\config; ..\..\..\..\..\..\..\..\..\components\ant\ant_channel_config; ..\..\..\..\..\..\..\..\..\components\ant\ant_key_manager; ..\..\..\..\..\..\..\..\..\components\ant\ant_key_manager\config; ..\..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_bpwr; ..\..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_bpwr\pages; ..\..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_bpwr\pages\logger; ..\..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_bpwr\simulator; ..\..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_bpwr\utils; ..\..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_common\pages; ..\..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_common\pages\logger; ..\..\..\..\..\..\..\..\..\components\ant\ant_stack_config; ..\..\..\..\..\..\..\..\..\components\ant\ant_state_indicator; ..\..\..\..\..\..\..\..\..\components\device; ..\..\..\..\..\..\..\..\..\components\drivers_ext\segger_rtt; ..\..\..\..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\..\..\..\components\softdevice\s212\headers; ..\..\..\..\..\..\..\..\..\components\softdevice\s212\headers\nrf52; ..\..\..\..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\..\..\bsp
  OBJCOPY.OOCOutputFile: ant_bpwr_tx_crank_torque_button_s212_pca10036.hex
  ILINK.IlinkOutputFile: ant_bpwr_tx_crank_torque_button_s212_pca10036.out
  ILINK.IlinkIcfFile: ant_bpwr_tx_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../../../../components/drivers_ext/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../../../components/libraries/util/: app_error.c nrf_assert.c nrf_log.c
    ../../../../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../../../../components/libraries/sensorsim/: sensorsim.c
  group Documentation
    ../../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_ANT
    ../../../../../../../../../components/ant/ant_profiles/ant_bpwr/: ant_bpwr.c
    ../../../../../../../../../components/ant/ant_profiles/ant_bpwr/pages/: ant_bpwr_common_data.c ant_bpwr_page_1.c ant_bpwr_page_16.c ant_bpwr_page_17.c ant_bpwr_page_18.c ant_bpwr_page_torque.c
    ../../../../../../../../../components/ant/ant_profiles/ant_bpwr/simulator/: ant_bpwr_simulator.c
    ../../../../../../../../../components/ant/ant_channel_config/: ant_channel_config.c
    ../../../../../../../../../components/ant/ant_profiles/ant_common/pages/: ant_common_page_80.c ant_common_page_81.c
    ../../../../../../../../../components/ant/ant_key_manager/: ant_key_manager.c
    ../../../../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
    ../../../../../../../../../components/ant/ant_state_indicator/: ant_state_indicator.c
  group Board Support
    ../../../../../../../../bsp/: bsp.c bsp_btn_ant.c
  group Application
    ../../../../: main.c
  group Device
    ../../../../../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../../../../../components/toolchain/: system_nrf52.c
  group nRF_SoftDevice
    ../../../../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
