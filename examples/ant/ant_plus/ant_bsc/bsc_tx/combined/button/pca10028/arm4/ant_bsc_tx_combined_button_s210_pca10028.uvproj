# Keil uVision project ant_bsc_tx_combined_button_s210_pca10028.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: ANT_STACK_SUPPORT_REQD MODIFICATION_TYPE=0 SENSOR_TYPE=0x79 ENABLE_DEBUG_LOG_SUPPORT TRACE_BSC_GENERAL_ENABLE TRACE_BSC_PAGE_0_ENABLE TRACE_BSC_PAGE_1_ENABLE TRACE_BSC_PAGE_2_ENABLE TRACE_BSC_PAGE_3_ENABLE TRACE_BSC_PAGE_4_ENABLE TRACE_BSC_PAGE_5_ENABLE TRACE_BSC_COMB_PAGE_0_ENABLE S210 BOARD_PCA10028 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0 NRF_LOG_USES_UART=1
  c misc: --c99
  c include: ..\..\..\..\config\ant_bsc_tx_combined_button_s210_pca10028;..\..\..\..\config;..\..\..\..\..\..\..\..\..\components\ant\ant_channel_config;..\..\..\..\..\..\..\..\..\components\ant\ant_key_manager;..\..\..\..\..\..\..\..\..\components\ant\ant_key_manager\config;..\..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_bsc;..\..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_bsc\pages;..\..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_bsc\pages\logger;..\..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_bsc\simulator;..\..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_bsc\utils;..\..\..\..\..\..\..\..\..\components\ant\ant_stack_config;..\..\..\..\..\..\..\..\..\components\ant\ant_state_indicator;..\..\..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\..\..\components\drivers_ext\segger_rtt;..\..\..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\..\..\..\components\softdevice\s210\headers;..\..\..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\..\..\bsp
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0xd000 size 0x33000
  memory RVCT9: RAM 0x20000900 size 0x7700
  group Application
    ../../../../: main.c
  group Board Support
    ../../../../../../../../bsp/: bsp.c bsp_btn_ant.c
  group Device
    ../../../../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../../: Abstract.txt license.txt
  group nRF_ANT
    ../../../../../../../../../components/ant/ant_profiles/ant_bsc/: ant_bsc.c
    ../../../../../../../../../components/ant/ant_profiles/ant_bsc/pages/: ant_bsc_combined_page_0.c ant_bsc_page_0.c ant_bsc_page_1.c ant_bsc_page_2.c ant_bsc_page_3.c ant_bsc_page_4.c ant_bsc_page_5.c
    ../../../../../../../../../components/ant/ant_profiles/ant_bsc/simulator/: ant_bsc_simulator.c
    ../../../../../../../../../components/ant/ant_channel_config/: ant_channel_config.c
    ../../../../../../../../../components/ant/ant_key_manager/: ant_key_manager.c
    ../../../../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
    ../../../../../../../../../components/ant/ant_state_indicator/: ant_state_indicator.c
  group nRF_Drivers
    ../../../../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../../../../../../../components/drivers_ext/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../../../components/libraries/util/: app_error.c nrf_assert.c nrf_log.c
    ../../../../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../../../../components/libraries/sensorsim/: sensorsim.c
  group nRF_SoftDevice
    ../../../../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s210_nrf51422_5.0.0_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: as above
  output: s210_nrf51422_5.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: ANT_STACK_SUPPORT_REQD MODIFICATION_TYPE=0 SENSOR_TYPE=0x79 ENABLE_DEBUG_LOG_SUPPORT TRACE_BSC_GENERAL_ENABLE TRACE_BSC_PAGE_0_ENABLE TRACE_BSC_PAGE_1_ENABLE TRACE_BSC_PAGE_2_ENABLE TRACE_BSC_PAGE_3_ENABLE TRACE_BSC_PAGE_4_ENABLE TRACE_BSC_PAGE_5_ENABLE TRACE_BSC_COMB_PAGE_0_ENABLE NRF51
  c misc: --c99
  c include: ..\..\..\..\config\ant_bsc_tx_combined_button_s210_pca10028;..\..\..\..\config;..\..\..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\..\..\components\toolchain
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
