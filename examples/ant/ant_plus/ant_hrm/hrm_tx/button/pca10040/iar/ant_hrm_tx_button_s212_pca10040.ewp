# IAR project ant_hrm_tx_button_s212_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ANT_STACK_SUPPORT_REQD; MODIFICATION_TYPE=0; ENABLE_DEBUG_LOG_SUPPORT; TRACE_HRM_GENERAL_ENABLE; TRACE_HRM_PAGE_0_ENABLE; TRACE_HRM_PAGE_1_ENABLE; TRACE_HRM_PAGE_2_ENABLE; TRACE_HRM_PAGE_3_ENABLE; TRACE_HRM_PAGE_4_ENABLE; S212; NRF52_PAN_53; NRF52_PAN_15; NRF52_PAN_54; NRF52_PAN_20; NRF52_PAN_55; NRF52_PAN_30; NRF52_PAN_58; NRF52_PAN_31; NRF52_PAN_62; NRF52_PAN_36; NRF52_PAN_63; NRF52_PAN_51; NRF52_PAN_64; CONFIG_GPIO_AS_PINRESET; BOARD_PCA10040; NRF52_PAN_12; NRF52; SOFTDEVICE_PRESENT; SWI_DISABLE0; NRF_LOG_USES_UART=1
  ICCARM.CCIncludePath2: ..\..\..\config\ant_hrm_tx_button_s212_pca10040; ..\..\..\config; ..\..\..\..\..\..\..\..\components\ant\ant_channel_config; ..\..\..\..\..\..\..\..\components\ant\ant_key_manager; ..\..\..\..\..\..\..\..\components\ant\ant_key_manager\config; ..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm; ..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\pages; ..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\pages\logger; ..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\simulator; ..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\utils; ..\..\..\..\..\..\..\..\components\ant\ant_stack_config; ..\..\..\..\..\..\..\..\components\ant\ant_state_indicator; ..\..\..\..\..\..\..\..\components\device; ..\..\..\..\..\..\..\..\components\drivers_ext\segger_rtt; ..\..\..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\..\..\components\softdevice\s212\headers; ..\..\..\..\..\..\..\..\components\softdevice\s212\headers\nrf52; ..\..\..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\..\bsp; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\..\config\ant_hrm_tx_button_s212_pca10040; ..\..\..\config; ..\..\..\..\..\..\..\..\components\ant\ant_channel_config; ..\..\..\..\..\..\..\..\components\ant\ant_key_manager; ..\..\..\..\..\..\..\..\components\ant\ant_key_manager\config; ..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm; ..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\pages; ..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\pages\logger; ..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\simulator; ..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\utils; ..\..\..\..\..\..\..\..\components\ant\ant_stack_config; ..\..\..\..\..\..\..\..\components\ant\ant_state_indicator; ..\..\..\..\..\..\..\..\components\device; ..\..\..\..\..\..\..\..\components\drivers_ext\segger_rtt; ..\..\..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\..\..\components\softdevice\s212\headers; ..\..\..\..\..\..\..\..\components\softdevice\s212\headers\nrf52; ..\..\..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\..\bsp
  OBJCOPY.OOCOutputFile: ant_hrm_tx_button_s212_pca10040.hex
  ILINK.IlinkOutputFile: ant_hrm_tx_button_s212_pca10040.out
  ILINK.IlinkIcfFile: ant_hrm_tx_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../../../components/drivers_ext/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../../components/libraries/util/: app_error.c nrf_assert.c nrf_log.c
    ../../../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../../../components/libraries/sensorsim/: sensorsim.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_ANT
    ../../../../../../../../components/ant/ant_channel_config/: ant_channel_config.c
    ../../../../../../../../components/ant/ant_profiles/ant_hrm/: ant_hrm.c
    ../../../../../../../../components/ant/ant_profiles/ant_hrm/pages/: ant_hrm_page_0.c ant_hrm_page_1.c ant_hrm_page_2.c ant_hrm_page_3.c ant_hrm_page_4.c
    ../../../../../../../../components/ant/ant_profiles/ant_hrm/simulator/: ant_hrm_simulator.c
    ../../../../../../../../components/ant/ant_key_manager/: ant_key_manager.c
    ../../../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
    ../../../../../../../../components/ant/ant_state_indicator/: ant_state_indicator.c
  group Board Support
    ../../../../../../../bsp/: bsp.c bsp_btn_ant.c
  group Application
    ../../../: main.c
  group Device
    ../../../../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../../../../components/toolchain/: system_nrf52.c
  group nRF_SoftDevice
    ../../../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
