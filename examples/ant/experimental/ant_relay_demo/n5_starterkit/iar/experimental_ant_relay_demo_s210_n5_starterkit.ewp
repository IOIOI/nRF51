# IAR project experimental_ant_relay_demo_s210_n5_starterkit.ewp, settings and files
configuration nrf51422_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxaa nRF51422_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ANT_STACK_SUPPORT_REQD; S210; BOARD_N5DK1; SWI_DISABLE0; NRF51; SOFTDEVICE_PRESENT
  ICCARM.CCIncludePath2: ..\..\config\experimental_ant_relay_demo_s210_n5_starterkit; ..\..\config; ..\..\..\..\..\..\components\ant\ant_stack_config; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\softdevice\s210\headers; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\bsp; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\config\experimental_ant_relay_demo_s210_n5_starterkit; ..\..\config; ..\..\..\..\..\..\components\ant\ant_stack_config; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\softdevice\s210\headers; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\bsp
  OBJCOPY.OOCOutputFile: experimental_ant_relay_demo_s210_n5_starterkit.hex
  ILINK.IlinkOutputFile: experimental_ant_relay_demo_s210_n5_starterkit.out
  ILINK.IlinkIcfFile: experimental_ant_relay_demo_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/timer/: app_timer.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/libraries/uart/: app_uart.c
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_ANT
    ../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
  group Board Support
    ../../../../../bsp/: bsp.c
  group Application
    ../../: main.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
