# IAR project experimental_ant_relay_demo_s212_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ANT_STACK_SUPPORT_REQD; S212; NRF52_PAN_53; NRF52_PAN_15; NRF52_PAN_54; NRF52_PAN_20; NRF52_PAN_55; NRF52_PAN_30; NRF52_PAN_58; NRF52_PAN_31; NRF52_PAN_62; NRF52_PAN_36; NRF52_PAN_63; NRF52_PAN_51; NRF52_PAN_64; CONFIG_GPIO_AS_PINRESET; BOARD_PCA10040; NRF52_PAN_12; SWI_DISABLE0; NRF52; SOFTDEVICE_PRESENT
  ICCARM.CCIncludePath2: ..\..\config\experimental_ant_relay_demo_s212_pca10040; ..\..\config; ..\..\..\..\..\..\components\ant\ant_stack_config; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\softdevice\s212\headers; ..\..\..\..\..\..\components\softdevice\s212\headers\nrf52; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\bsp; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\config\experimental_ant_relay_demo_s212_pca10040; ..\..\config; ..\..\..\..\..\..\components\ant\ant_stack_config; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\softdevice\s212\headers; ..\..\..\..\..\..\components\softdevice\s212\headers\nrf52; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\bsp
  OBJCOPY.OOCOutputFile: experimental_ant_relay_demo_s212_pca10040.hex
  ILINK.IlinkOutputFile: experimental_ant_relay_demo_s212_pca10040.out
  ILINK.IlinkIcfFile: experimental_ant_relay_demo_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/timer/: app_timer.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/libraries/uart/: app_uart.c
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_ANT
    ../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
  group Board Support
    ../../../../../bsp/: bsp.c
  group Application
    ../../: main.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
