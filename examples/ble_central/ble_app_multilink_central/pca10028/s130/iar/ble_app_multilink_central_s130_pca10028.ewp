# IAR project ble_app_multilink_central_s130_pca10028.ewp, settings and files
configuration nrf51422_xxac_s130 (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __HEAP_SIZE=0; BLE_STACK_SUPPORT_REQD; S130; BOARD_PCA10028; BSP_DEFINES_ONLY; NRF51; SOFTDEVICE_PRESENT; SWI_DISABLE0; NRF_LOG_USES_UART=1
  ICCARM.CCIncludePath2: ..\..\..\config\ble_app_multilink_central_s130_pca10028; ..\..\..\config; ..\..\..\..\..\..\components\ble\ble_db_discovery; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\ble\device_manager; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_ext\segger_rtt; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\pstorage; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\softdevice\s130\headers; ..\..\..\..\..\..\components\softdevice\s130\headers\nrf51; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\bsp; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\..\config\ble_app_multilink_central_s130_pca10028; ..\..\..\config; ..\..\..\..\..\..\components\ble\ble_db_discovery; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\ble\device_manager; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_ext\segger_rtt; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\pstorage; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\softdevice\s130\headers; ..\..\..\..\..\..\components\softdevice\s130\headers\nrf51; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\bsp
  OBJCOPY.OOCOutputFile: ble_app_multilink_central_s130_pca10028.hex
  ILINK.IlinkOutputFile: ble_app_multilink_central_s130_pca10028.out
  ILINK.IlinkIcfFile: ble_app_multilink_central_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../components/drivers_ext/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c nrf_log.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/uart/: retarget.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group Application
    ../../../: client_handling.c main.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../../../../../components/ble/device_manager/: device_manager_central.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s130/doc/: s130_nrf51_2.0.0-7.alpha_licence_agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
