# Keil uVision project ble_app_rscs_c_s132_pca10040.uvproj, settings and files
target nrf52832_xxaa_s132 (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s132 +hex
  c flags: Optim=4 OneElfS=1
  c define: __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD S132 NRF52_PAN_53 NRF52_PAN_15 NRF52_PAN_54 NRF52_PAN_20 NRF52_PAN_55 NRF52_PAN_30 NRF52_PAN_58 NRF52_PAN_31 NRF52_PAN_62 NRF52_PAN_36 NRF52_PAN_63 NRF52_PAN_51 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET BOARD_PCA10040 NRF52_PAN_12 BSP_UART_SUPPORT SOFTDEVICE_PRESENT NRF52 SWI_DISABLE0 NRF_LOG_USES_UART=1
  c misc: --c99
  c include: ..\..\..\config\ble_app_rscs_c_s132_pca10040;..\..\..\config;..\..\..\..\..\..\..\components\ble\ble_db_discovery;..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\..\components\ble\device_manager;..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\components\drivers_ext\segger_rtt;..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\bsp
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x65000
  memory RVCT9: RAM 0x20001d80 size 0x6280
  group Application
    ../../../: main.c
  group Board Support
    ../../../../../../bsp/: bsp.c bsp_btn_ble.c
  group Device
    ../../../../../../../components/toolchain/arm/: arm_startup_nrf52.s
    ../../../../../../../components/toolchain/: system_nrf52.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../../../../../../components/ble/ble_services/ble_rscs_c/: ble_rscs_c.c
    ../../../../../../../components/ble/device_manager/: device_manager_central.c
  group nRF_Drivers
    ../../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../../../../components/drivers_ext/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c nrf_assert.c nrf_log.c
    ../../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../../components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    ../../../../../../../components/softdevice/s132/doc/: s132_nrf52_2.0.0-7.alpha_licence_agreement.txt
    ../../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
