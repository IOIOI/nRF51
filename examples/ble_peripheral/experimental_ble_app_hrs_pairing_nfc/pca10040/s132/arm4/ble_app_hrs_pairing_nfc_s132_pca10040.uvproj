# Keil uVision project ble_app_hrs_pairing_nfc_s132_pca10040.uvproj, settings and files
target nrf58232_xxaa_s132 (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf58232_xxaa_s132 +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 S132 NRF52_PAN_53 NRF52_PAN_15 NRF52_PAN_54 NRF52_PAN_20 NRF52_PAN_55 NRF52_PAN_30 NRF52_PAN_58 NRF52_PAN_31 NRF52_PAN_62 NRF52_PAN_36 NRF52_PAN_63 NRF52_PAN_51 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET BOARD_PCA10040 NRF52_PAN_12 NRF_LOG_USES_UART=1 SOFTDEVICE_PRESENT NRF52 SWI_DISABLE0
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\device_manager;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\drivers_ext\segger_rtt;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\experimental_nfc\ndef\connection_handover;..\..\..\..\..\..\components\experimental_nfc\ndef\connection_handover\ac_rec;..\..\..\..\..\..\components\experimental_nfc\ndef\connection_handover\ep_oob_rec;..\..\..\..\..\..\components\experimental_nfc\ndef\connection_handover\hs_rec;..\..\..\..\..\..\components\experimental_nfc\ndef\connection_handover\le_oob_rec;..\..\..\..\..\..\components\experimental_nfc\ndef\generic\message;..\..\..\..\..\..\components\experimental_nfc\ndef\generic\record;..\..\..\..\..\..\components\experimental_nfc\t2t_lib;..\..\..\..\..\..\components\experimental_nfc\t2t_lib\hal_t2t;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\bsp
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x65000
  memory RVCT9: RAM 0x20004300 size 0x3d00
  group Application
    ../../../: main.c
  group Board Support
    ../../../../../bsp/: bsp.c bsp_btn_ble.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../../../components/ble/ble_services/ble_hrs/: ble_hrs.c
    ../../../../../../components/ble/device_manager/: device_manager_peripheral.c
  group nRF_Drivers
    ../../../../../../components/libraries/uart/: app_uart.c
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../../../components/drivers_ext/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c nrf_log.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../components/libraries/sensorsim/: sensorsim.c
  group nRF_NFC
    ../../../../../../components/experimental_nfc/t2t_lib/hal_t2t/: hal_nfc_t2t.c
    ../../../../../../components/experimental_nfc/ndef/connection_handover/ac_rec/: nfc_ac_rec.c
    ../../../../../../components/experimental_nfc/ndef/connection_handover/: nfc_ble_pair_msg.c
    ../../../../../../components/experimental_nfc/ndef/connection_handover/ep_oob_rec/: nfc_ep_oob_rec.c
    ../../../../../../components/experimental_nfc/ndef/connection_handover/hs_rec/: nfc_hs_rec.c
    ../../../../../../components/experimental_nfc/ndef/connection_handover/le_oob_rec/: nfc_le_oob_rec.c
    ../../../../../../components/experimental_nfc/ndef/generic/message/: nfc_ndef_msg.c
    ../../../../../../components/experimental_nfc/ndef/generic/record/: nfc_ndef_record.c
    ../../../../../../components/experimental_nfc/t2t_lib/: nfc_t2t_lib_keil.lib
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s132/doc/: s132_nrf52_2.0.0-7.alpha_licence_agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s132_nrf52_2.0.0-7.alpha_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: as above
  output: s132_nrf52_2.0.0-7.alpha_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 NRF52
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain
  asm define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 NRF52
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
