# IAR project ble_app_hrs_pairing_nfc_s132_pca10040.ewp, settings and files
configuration nrf58232_xxaa_s132 (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; __HEAP_SIZE=0; S132; NRF52_PAN_53; NRF52_PAN_15; NRF52_PAN_54; NRF52_PAN_20; NRF52_PAN_55; NRF52_PAN_30; NRF52_PAN_58; NRF52_PAN_31; NRF52_PAN_62; NRF52_PAN_36; NRF52_PAN_63; NRF52_PAN_51; NRF52_PAN_64; CONFIG_GPIO_AS_PINRESET; BOARD_PCA10040; NRF52_PAN_12; NRF_LOG_USES_UART=1; SOFTDEVICE_PRESENT; NRF52; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\components\ble\ble_advertising; ..\..\..\..\..\..\components\ble\ble_services\ble_bas; ..\..\..\..\..\..\components\ble\ble_services\ble_dis; ..\..\..\..\..\..\components\ble\ble_services\ble_hrs; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\ble\device_manager; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_ext\segger_rtt; ..\..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\pstorage; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\experimental_nfc\ndef\connection_handover; ..\..\..\..\..\..\components\experimental_nfc\ndef\connection_handover\ac_rec; ..\..\..\..\..\..\components\experimental_nfc\ndef\connection_handover\ep_oob_rec; ..\..\..\..\..\..\components\experimental_nfc\ndef\connection_handover\hs_rec; ..\..\..\..\..\..\components\experimental_nfc\ndef\connection_handover\le_oob_rec; ..\..\..\..\..\..\components\experimental_nfc\ndef\generic\message; ..\..\..\..\..\..\components\experimental_nfc\ndef\generic\record; ..\..\..\..\..\..\components\experimental_nfc\t2t_lib; ..\..\..\..\..\..\components\experimental_nfc\t2t_lib\hal_t2t; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\softdevice\s132\headers; ..\..\..\..\..\..\components\softdevice\s132\headers\nrf52; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\bsp; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\..\config; ..\..\..\..\..\..\components\ble\ble_advertising; ..\..\..\..\..\..\components\ble\ble_services\ble_bas; ..\..\..\..\..\..\components\ble\ble_services\ble_dis; ..\..\..\..\..\..\components\ble\ble_services\ble_hrs; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\ble\device_manager; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_ext\segger_rtt; ..\..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\pstorage; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\experimental_nfc\ndef\connection_handover; ..\..\..\..\..\..\components\experimental_nfc\ndef\connection_handover\ac_rec; ..\..\..\..\..\..\components\experimental_nfc\ndef\connection_handover\ep_oob_rec; ..\..\..\..\..\..\components\experimental_nfc\ndef\connection_handover\hs_rec; ..\..\..\..\..\..\components\experimental_nfc\ndef\connection_handover\le_oob_rec; ..\..\..\..\..\..\components\experimental_nfc\ndef\generic\message; ..\..\..\..\..\..\components\experimental_nfc\ndef\generic\record; ..\..\..\..\..\..\components\experimental_nfc\t2t_lib; ..\..\..\..\..\..\components\experimental_nfc\t2t_lib\hal_t2t; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\softdevice\s132\headers; ..\..\..\..\..\..\components\softdevice\s132\headers\nrf52; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\bsp
  OBJCOPY.OOCOutputFile: ble_app_hrs_pairing_nfc_s132_pca10040.hex
  ILINK.IlinkOutputFile: ble_app_hrs_pairing_nfc_s132_pca10040.out
  ILINK.IlinkIcfFile: ble_app_hrs_pairing_nfc_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../components/drivers_ext/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c nrf_log.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../components/libraries/sensorsim/: sensorsim.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/libraries/uart/: app_uart.c
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group Board Support
    ../../../../../bsp/: bsp.c bsp_btn_ble.c
  group Application
    ../../../: main.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../../../components/ble/ble_services/ble_hrs/: ble_hrs.c
    ../../../../../../components/ble/device_manager/: device_manager_peripheral.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
  group nRF_NFC
    ../../../../../../components/experimental_nfc/t2t_lib/hal_t2t/: hal_nfc_t2t.c
    ../../../../../../components/experimental_nfc/ndef/connection_handover/ac_rec/: nfc_ac_rec.c
    ../../../../../../components/experimental_nfc/ndef/connection_handover/: nfc_ble_pair_msg.c
    ../../../../../../components/experimental_nfc/ndef/connection_handover/ep_oob_rec/: nfc_ep_oob_rec.c
    ../../../../../../components/experimental_nfc/ndef/connection_handover/hs_rec/: nfc_hs_rec.c
    ../../../../../../components/experimental_nfc/ndef/connection_handover/le_oob_rec/: nfc_le_oob_rec.c
    ../../../../../../components/experimental_nfc/ndef/generic/message/: nfc_ndef_msg.c
    ../../../../../../components/experimental_nfc/ndef/generic/record/: nfc_ndef_record.c
    ../../../../../../components/experimental_nfc/t2t_lib/: nfc_t2t_lib_iar.a
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s132/doc/: s132_nrf52_2.0.0-7.alpha_licence_agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
