# IAR project dfu_single_bank_serial_s132_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; __HEAP_SIZE=0; NRF52_PAN_53; NRF52_PAN_15; NRF52_PAN_54; NRF52_PAN_20; NRF52_PAN_55; NRF52_PAN_30; NRF52_PAN_58; NRF52_PAN_31; NRF52_PAN_62; NRF52_PAN_36; NRF52_PAN_63; NRF52_PAN_51; NRF52_PAN_64; CONFIG_GPIO_AS_PINRESET; BOARD_PCA10040; NRF52_PAN_12; S132; BSP_DEFINES_ONLY; NRF52; SOFTDEVICE_PRESENT; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\..\config\dfu_single_bank_serial_s132_pca10040; ..\..\..\config; ..\..\..\..\..\..\components\libraries\bootloader_dfu\hci_transport; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\pstorage; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\bootloader_dfu; ..\..\..\..\..\..\components\libraries\crc16; ..\..\..\..\..\..\components\libraries\hci; ..\..\..\..\..\..\components\libraries\hci\config; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\softdevice\s132\headers; ..\..\..\..\..\..\components\softdevice\s132\headers\nrf52; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\bsp; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\..\config\dfu_single_bank_serial_s132_pca10040; ..\..\..\config; ..\..\..\..\..\..\components\libraries\bootloader_dfu\hci_transport; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\pstorage; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\bootloader_dfu; ..\..\..\..\..\..\components\libraries\crc16; ..\..\..\..\..\..\components\libraries\hci; ..\..\..\..\..\..\components\libraries\hci\config; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\softdevice\s132\headers; ..\..\..\..\..\..\components\softdevice\s132\headers\nrf52; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\bsp
  OBJCOPY.OOCOutputFile: dfu_single_bank_serial_s132_pca10040.hex
  ILINK.IlinkOutputFile: dfu_single_bank_serial_s132_pca10040.out
  ILINK.IlinkIcfFile: dfu_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../../../../components/libraries/bootloader_dfu/: bootloader.c bootloader_settings.c bootloader_util.c dfu_init_template.c dfu_single_bank.c dfu_transport_serial.c
    ../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../components/libraries/hci/: hci_mem_pool.c hci_slip.c hci_transport.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/libraries/uart/: app_uart.c
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage_raw.c
  group Application
    ../../../: main.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s132/doc/: s132_nrf52_2.0.0-7.alpha_licence_agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
