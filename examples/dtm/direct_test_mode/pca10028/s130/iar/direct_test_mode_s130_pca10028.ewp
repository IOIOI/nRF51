# IAR project direct_test_mode_s130_pca10028.ewp, settings and files
configuration nrf5422_xxaa_s130 (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BSP_DEFINES_ONLY; BOARD_PCA10028; S130; NRF51; SOFTDEVICE_PRESENT
  ICCARM.CCIncludePath2: ..\..\..\config\direct_test_mode_s130_pca10028; ..\..\..\config; ..\..\..\..\..\..\components\ble\ble_dtm; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\softdevice\s130\headers; ..\..\..\..\..\..\components\softdevice\s130\headers\nrf51; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\bsp; ..\..\..; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\..\config\direct_test_mode_s130_pca10028; ..\..\..\config; ..\..\..\..\..\..\components\ble\ble_dtm; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\softdevice\s130\headers; ..\..\..\..\..\..\components\softdevice\s130\headers\nrf51; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\bsp; ..\..\..
  OBJCOPY.OOCOutputFile: direct_test_mode_s130_pca10028.hex
  ILINK.IlinkOutputFile: direct_test_mode_s130_pca10028.out
  ILINK.IlinkIcfFile: direct_test_mode_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Application
    ../../../: main.c
  group nRF_BLE
    ../../../../../../components/ble/ble_dtm/: ble_dtm.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s130/doc/: s130_nrf51_2.0.0-7.alpha_licence_agreement.txt
  group Documentation
    ../../../: Abstract.txt license.txt
