# Keil uVision project nfc_launchapp_record_pca10036.uvproj, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1
  c define: BSP_DEFINES_ONLY NRF52_PAN_8 NRF52_PAN_9 NRF52_PAN_10 NRF52_PAN_11 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_16 NRF52_PAN_17 NRF52_PAN_20 NRF52_PAN_23 NRF52_PAN_24 NRF52_PAN_25 NRF52_PAN_26 NRF52_PAN_27 NRF52_PAN_28 NRF52_PAN_29 NRF52_PAN_30 NRF52_PAN_32 NRF52_PAN_33 NRF52_PAN_34 NRF52_PAN_35 NRF52_PAN_36 NRF52_PAN_37 NRF52_PAN_38 NRF52_PAN_39 NRF52_PAN_40 NRF52_PAN_41 NRF52_PAN_42 NRF52_PAN_43 NRF52_PAN_44 NRF52_PAN_46 NRF52_PAN_47 NRF52_PAN_48 NRF52_PAN_49 NRF52_PAN_58 NRF52_PAN_63 NRF52_PAN_64 NRF52_PAN_65 CONFIG_GPIO_AS_PINRESET BOARD_PCA10036 NRF52_PAN_1 NRF52_PAN_2 NRF52_PAN_3 NRF52_PAN_4 NRF52_PAN_7 NRF52 NRF_LOG_USES_UART=1
  c misc: --c99
  c include: ..\..\config;..\..\..\..\..\components\device;..\..\..\..\..\components\drivers_ext\segger_rtt;..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\components\experimental_nfc\ndef\generic\message;..\..\..\..\..\components\experimental_nfc\ndef\generic\record;..\..\..\..\..\components\experimental_nfc\ndef\launchapp;..\..\..\..\..\components\experimental_nfc\t2t_lib;..\..\..\..\..\components\experimental_nfc\t2t_lib\hal_t2t;..\..\..\..\..\components\libraries\trace;..\..\..\..\..\components\libraries\uart;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\toolchain;..\..\..\..\bsp;..\..
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: main.c
  group Device
    ../../../../../components/toolchain/arm/: arm_startup_nrf52.s
    ../../../../../components/toolchain/: system_nrf52.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/libraries/uart/: app_uart.c
    ../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_soc.c
  group nRF_Libraries
    ../../../../../components/drivers_ext/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c nrf_log.c
    ../../../../../components/libraries/trace/: app_trace.c
    ../../../../../components/libraries/uart/: retarget.c
  group nRF_NFC
    ../../../../../components/experimental_nfc/t2t_lib/hal_t2t/: hal_nfc_t2t.c
    ../../../../../components/experimental_nfc/ndef/launchapp/: nfc_launchapp_msg.c nfc_launchapp_rec.c
    ../../../../../components/experimental_nfc/ndef/generic/message/: nfc_ndef_msg.c
    ../../../../../components/experimental_nfc/ndef/generic/record/: nfc_ndef_record.c
    ../../../../../components/experimental_nfc/t2t_lib/: nfc_t2t_lib_keil.lib
