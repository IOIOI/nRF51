# IAR project blinky_FreeRTOS_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BSP_DEFINES_ONLY; BOARD_PCA10028; NRF51; FREERTOS
  ICCARM.CCIncludePath2: ..\..\config\blinky_FreeRTOS_pca10028; ..\..\config; ..\..\..\..\..\components\device; ..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\toolchain; ..\..\..\..\bsp; ..\..; ..\..\..\..\..\external\freertos\config; ..\..\..\..\..\external\freertos\portable\CMSIS\nrf51; ..\..\..\..\..\external\freertos\portable\IAR\nrf51; ..\..\..\..\..\external\freertos\source\include; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BSP_DEFINES_ONLY; BOARD_PCA10028; NRF51; FREERTOS
  AARM.AUserIncludes: ..\..\config\blinky_FreeRTOS_pca10028; ..\..\config; ..\..\..\..\..\components\device; ..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\toolchain; ..\..\..\..\bsp; ..\..; ..\..\..\..\..\external\freertos\config; ..\..\..\..\..\external\freertos\portable\CMSIS\nrf51; ..\..\..\..\..\external\freertos\portable\IAR\nrf51; ..\..\..\..\..\external\freertos\source\include
  OBJCOPY.OOCOutputFile: blinky_FreeRTOS_pca10028.hex
  ILINK.IlinkOutputFile: blinky_FreeRTOS_pca10028.out
  ILINK.IlinkIcfFile: blinky_FreeRTOS_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c
  group Third Parties
    ../../../../../external/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../external/freertos/source/portable/MemMang/: heap_1.c
    ../../../../../external/freertos/portable/IAR/nrf51/: port.c
    ../../../../../external/freertos/portable/CMSIS/nrf51/: port_cmsis.c port_cmsis_systick.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_soc.c
  group Application
    ../../: main.c
  group Device
    ../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
