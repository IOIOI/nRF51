# IAR project blinky_FreeRTOS_pca10036.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BSP_DEFINES_ONLY; NRF52_PAN_8; NRF52_PAN_9; NRF52_PAN_10; NRF52_PAN_11; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_16; NRF52_PAN_17; NRF52_PAN_20; NRF52_PAN_23; NRF52_PAN_24; NRF52_PAN_25; NRF52_PAN_26; NRF52_PAN_27; NRF52_PAN_28; NRF52_PAN_29; NRF52_PAN_30; NRF52_PAN_32; NRF52_PAN_33; NRF52_PAN_34; NRF52_PAN_35; NRF52_PAN_36; NRF52_PAN_37; NRF52_PAN_38; NRF52_PAN_39; NRF52_PAN_40; NRF52_PAN_41; NRF52_PAN_42; NRF52_PAN_43; NRF52_PAN_44; NRF52_PAN_46; NRF52_PAN_47; NRF52_PAN_48; NRF52_PAN_49; NRF52_PAN_58; NRF52_PAN_63; NRF52_PAN_64; NRF52_PAN_65; CONFIG_GPIO_AS_PINRESET; BOARD_PCA10036; NRF52_PAN_1; NRF52_PAN_2; NRF52_PAN_3; NRF52_PAN_4; NRF52_PAN_7; NRF52; FREERTOS
  ICCARM.CCIncludePath2: ..\..\config\blinky_FreeRTOS_pca10036; ..\..\config; ..\..\..\..\..\components\device; ..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\toolchain; ..\..\..\..\bsp; ..\..; ..\..\..\..\..\external\freertos\config; ..\..\..\..\..\external\freertos\portable\CMSIS\nrf52; ..\..\..\..\..\external\freertos\portable\IAR\nrf52; ..\..\..\..\..\external\freertos\source\include; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\config\blinky_FreeRTOS_pca10036; ..\..\config; ..\..\..\..\..\components\device; ..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\toolchain; ..\..\..\..\bsp; ..\..; ..\..\..\..\..\external\freertos\config; ..\..\..\..\..\external\freertos\portable\CMSIS\nrf52; ..\..\..\..\..\external\freertos\portable\IAR\nrf52; ..\..\..\..\..\external\freertos\source\include
  OBJCOPY.OOCOutputFile: blinky_FreeRTOS_pca10036.hex
  ILINK.IlinkOutputFile: blinky_FreeRTOS_pca10036.out
  ILINK.IlinkIcfFile: blinky_FreeRTOS_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c
  group Third Parties
    ../../../../../external/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../external/freertos/source/portable/MemMang/: heap_1.c
    ../../../../../external/freertos/portable/IAR/nrf52/: port.c
    ../../../../../external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_soc.c
  group Application
    ../../: main.c
  group Device
    ../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../components/toolchain/: system_nrf52.c
