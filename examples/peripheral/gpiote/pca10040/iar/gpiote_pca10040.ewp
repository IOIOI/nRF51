# IAR project gpiote_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BSP_DEFINES_ONLY; NRF52_PAN_53; NRF52_PAN_15; NRF52_PAN_54; NRF52_PAN_20; NRF52_PAN_55; NRF52_PAN_30; NRF52_PAN_58; NRF52_PAN_31; NRF52_PAN_62; NRF52_PAN_36; NRF52_PAN_63; NRF52_PAN_51; NRF52_PAN_64; CONFIG_GPIO_AS_PINRESET; BOARD_PCA10040; NRF52_PAN_12; NRF52
  ICCARM.CCIncludePath2: ..\..\config\gpiote_pca10040; ..\..\config; ..\..\..\..\..\components\device; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\components\drivers_nrf\ppi; ..\..\..\..\..\components\drivers_nrf\timer; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\toolchain; ..\..\..\..\bsp; ..\..; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\config\gpiote_pca10040; ..\..\config; ..\..\..\..\..\components\device; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\components\drivers_nrf\ppi; ..\..\..\..\..\components\drivers_nrf\timer; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\toolchain; ..\..\..\..\bsp; ..\..
  OBJCOPY.OOCOutputFile: gpiote_pca10040.hex
  ILINK.IlinkOutputFile: gpiote_pca10040.out
  ILINK.IlinkIcfFile: gpiote_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Device
    ../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../components/toolchain/: system_nrf52.c
  group Application
    ../../: main.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c
  group nRF_Drivers
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
  group Documentation
    ../../: Abstract.txt license.txt
