# IAR project led_softblink_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10028; BSP_DEFINES_ONLY; NRF51; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\..\config\led_softblink_pca10028; ..\..\..\config; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\led_softblink; ..\..\..\..\..\..\components\libraries\low_power_pwm; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\bsp; ..\..\..; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_PCA10028; BSP_DEFINES_ONLY; NRF51; SWI_DISABLE0
  AARM.AUserIncludes: ..\..\..\config\led_softblink_pca10028; ..\..\..\config; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\led_softblink; ..\..\..\..\..\..\components\libraries\low_power_pwm; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\bsp; ..\..\..
  OBJCOPY.OOCOutputFile: led_softblink_pca10028.hex
  ILINK.IlinkOutputFile: led_softblink_pca10028.out
  ILINK.IlinkIcfFile: led_softblink_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Application
    ../../../: main.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/led_softblink/: led_softblink.c
    ../../../../../../components/libraries/low_power_pwm/: low_power_pwm.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_soc.c
  group Documentation
    ../../../: Abstract.txt license.txt
