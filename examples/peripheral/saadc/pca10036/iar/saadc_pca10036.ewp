# IAR project saadc_pca10036.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BSP_DEFINES_ONLY; NRF52_PAN_8; NRF52_PAN_9; NRF52_PAN_10; NRF52_PAN_11; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_16; NRF52_PAN_17; NRF52_PAN_20; NRF52_PAN_23; NRF52_PAN_24; NRF52_PAN_25; NRF52_PAN_26; NRF52_PAN_27; NRF52_PAN_28; NRF52_PAN_29; NRF52_PAN_30; NRF52_PAN_32; NRF52_PAN_33; NRF52_PAN_34; NRF52_PAN_35; NRF52_PAN_36; NRF52_PAN_37; NRF52_PAN_38; NRF52_PAN_39; NRF52_PAN_40; NRF52_PAN_41; NRF52_PAN_42; NRF52_PAN_43; NRF52_PAN_44; NRF52_PAN_46; NRF52_PAN_47; NRF52_PAN_48; NRF52_PAN_49; NRF52_PAN_58; NRF52_PAN_63; NRF52_PAN_64; NRF52_PAN_65; CONFIG_GPIO_AS_PINRESET; BOARD_PCA10036; NRF52_PAN_1; NRF52_PAN_2; NRF52_PAN_3; NRF52_PAN_4; NRF52_PAN_7; NRF52
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\components\device; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\components\drivers_nrf\ppi; ..\..\..\..\..\components\drivers_nrf\saadc; ..\..\..\..\..\components\drivers_nrf\timer; ..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\toolchain; ..\..\..\..\bsp; ..\..; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\config; ..\..\..\..\..\components\device; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\components\drivers_nrf\ppi; ..\..\..\..\..\components\drivers_nrf\saadc; ..\..\..\..\..\components\drivers_nrf\timer; ..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\toolchain; ..\..\..\..\bsp; ..\..
  OBJCOPY.OOCOutputFile: saadc_pca10036.hex
  ILINK.IlinkOutputFile: saadc_pca10036.out
  ILINK.IlinkIcfFile: saadc_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Device
    ../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../components/toolchain/: system_nrf52.c
  group Application
    ../../: main.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c
    ../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../components/libraries/uart/: retarget.c
  group nRF_Drivers
    ../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../../../../components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../components/drivers_nrf/hal/: nrf_saadc.c
  group Documentation
    ../../: Abstract.txt license.txt
