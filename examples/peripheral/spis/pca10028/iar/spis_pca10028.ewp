# IAR project spis_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NRF_LOG_USES_RTT=1; BOARD_PCA10028; NRF_LOG_USES_UART=1; NRF51; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\config\spis_pca10028; ..\..\config; ..\..\..\..\..\components\device; ..\..\..\..\..\components\drivers_ext\segger_rtt; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\components\drivers_nrf\spi_slave; ..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\components\libraries\button; ..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\toolchain; ..\..\..\..\bsp; ..\..; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\config\spis_pca10028; ..\..\config; ..\..\..\..\..\components\device; ..\..\..\..\..\components\drivers_ext\segger_rtt; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\components\drivers_nrf\spi_slave; ..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\components\libraries\button; ..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\toolchain; ..\..\..\..\bsp; ..\..
  OBJCOPY.OOCOutputFile: spis_pca10028.hex
  ILINK.IlinkOutputFile: spis_pca10028.out
  ILINK.IlinkIcfFile: spis_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../components/drivers_ext/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c nrf_log.c
    ../../../../../components/libraries/timer/: app_timer.c
    ../../../../../components/libraries/uart/: retarget.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/libraries/uart/: app_uart.c
    ../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../components/drivers_nrf/spi_slave/: nrf_drv_spis.c
    ../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group Board Support
    ../../../../bsp/: bsp.c
  group Application
    ../../: main.c
  group Device
    ../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
