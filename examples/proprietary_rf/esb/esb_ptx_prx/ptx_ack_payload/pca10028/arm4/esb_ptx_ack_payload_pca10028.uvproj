# Keil uVision project esb_ptx_ack_payload_pca10028.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: BSP_DEFINES_ONLY BOARD_PCA10028 ESB_PRESENT NRF51
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\components\properitary_rf\esb;..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\bsp
  asm define: BSP_DEFINES_ONLY BOARD_PCA10028 ESB_PRESENT NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../../: main_esb_ptx_ack_payload.c
  group Device
    ../../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Properitary_RF
    ../../../../../../../components/properitary_rf/esb/arm/: esb_arm.lib
