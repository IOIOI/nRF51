# IAR project esb_ptx_ack_payload_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BSP_DEFINES_ONLY; BOARD_PCA10028; ESB_PRESENT; NRF51
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\..\components\device; ..\..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\..\components\properitary_rf\esb; ..\..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\bsp; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BSP_DEFINES_ONLY; BOARD_PCA10028; ESB_PRESENT; NRF51
  AARM.AUserIncludes: ..\..\..\config; ..\..\..\..\..\..\..\components\device; ..\..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\..\components\properitary_rf\esb; ..\..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\bsp
  OBJCOPY.OOCOutputFile: esb_ptx_ack_payload_pca10028.hex
  ILINK.IlinkOutputFile: esb_ptx_ack_payload_pca10028.out
  ILINK.IlinkIcfFile: esb_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Device
    ../../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../../components/toolchain/: system_nrf51.c
  group Application
    ../../../: main_esb_ptx_ack_payload.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Properitary_RF
    ../../../../../../../components/properitary_rf/esb/iar/: esb_iar.a
