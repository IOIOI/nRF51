# IAR project gzp_desktop_emulator_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10028; BSP_UART_SUPPORT; BSP_SIMPLE; GAZELL_PRESENT; NRF51; NRF_LOG_USES_UART=1
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_ext\segger_rtt; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\properitary_rf\gzll; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\bsp; ..\..; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\config; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_ext\segger_rtt; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\properitary_rf\gzll; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\bsp; ..\..
  OBJCOPY.OOCOutputFile: gzp_desktop_emulator_pca10028.hex
  ILINK.IlinkOutputFile: gzp_desktop_emulator_pca10028.out
  ILINK.IlinkIcfFile: ..\..\..\gzp_device_iar_nrf51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../components/drivers_ext/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c nrf_log.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/uart/: retarget.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/hal/: nrf_ecb.c nrf_nvmc.c
  group Board Support
    ../../../../../bsp/: bsp.c
  group Application
    ../../: keyboard_emulator.c main_mouse_keyboard_emulator_nrf51.c mouse_sensor_emulator.c
  group nRF_Properitary_RF
    ../../../../../../components/properitary_rf/gzll/iar/: gzll_iar.a
    ../../../../../../components/properitary_rf/gzll/: nrf_gzp.c nrf_gzp_device.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
