# IAR project gzp_device_dynamic_pairing_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10028; GAZELL_PRESENT; BSP_DEFINES_ONLY; NRF51
  ICCARM.CCIncludePath2: ..\..\..\config\gzp_device_dynamic_pairing_pca10028; ..\..\..\config; ..\..\..\..\..\..\..\components\device; ..\..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\..\components\properitary_rf\gzll; ..\..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\bsp; ..\..\..; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_PCA10028; GAZELL_PRESENT; BSP_DEFINES_ONLY; NRF51
  AARM.AUserIncludes: ..\..\..\config\gzp_device_dynamic_pairing_pca10028; ..\..\..\config; ..\..\..\..\..\..\..\components\device; ..\..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\..\components\properitary_rf\gzll; ..\..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\bsp; ..\..\..
  OBJCOPY.OOCOutputFile: gzp_device_dynamic_pairing_pca10028.hex
  ILINK.IlinkOutputFile: gzp_device_dynamic_pairing_pca10028.out
  ILINK.IlinkIcfFile: ..\..\..\..\gzp_device_iar_nrf51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Device
    ../../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../../components/toolchain/: system_nrf51.c
  group Application
    ../../../: main_device_dynamic_pairing.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../../components/drivers_nrf/hal/: nrf_ecb.c nrf_nvmc.c
  group nRF_Properitary_RF
    ../../../../../../../components/properitary_rf/gzll/iar/: gzll_iar.a
    ../../../../../../../components/properitary_rf/gzll/: nrf_gzp.c nrf_gzp_device.c
