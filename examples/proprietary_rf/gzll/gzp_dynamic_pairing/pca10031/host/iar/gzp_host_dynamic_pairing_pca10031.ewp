# IAR project gzp_host_dynamic_pairing_pca10031.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10031; GAZELL_PRESENT; BSP_DEFINES_ONLY; NRF51
  ICCARM.CCIncludePath2: ..\..\..\config\gzp_host_dynamic_pairing_pca10031; ..\..\..\config; ..\..\..\..\..\..\..\components\device; ..\..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\components\properitary_rf\gzll; ..\..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\bsp; ..\..\..; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_PCA10031; GAZELL_PRESENT; BSP_DEFINES_ONLY; NRF51
  AARM.AUserIncludes: ..\..\..\config\gzp_host_dynamic_pairing_pca10031; ..\..\..\config; ..\..\..\..\..\..\..\components\device; ..\..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\components\properitary_rf\gzll; ..\..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\bsp; ..\..\..
  OBJCOPY.OOCOutputFile: gzp_host_dynamic_pairing_pca10031.hex
  ILINK.IlinkOutputFile: gzp_host_dynamic_pairing_pca10031.out
  ILINK.IlinkIcfFile: gzp_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../../components/libraries/util/: app_error.c nrf_assert.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../../components/drivers_nrf/hal/: nrf_ecb.c nrf_nvmc.c
  group Application
    ../../../: main_host_dynamic_pairing.c
  group nRF_Properitary_RF
    ../../../../../../../components/properitary_rf/gzll/iar/: gzll_iar.a
    ../../../../../../../components/properitary_rf/gzll/: nrf_gzp.c nrf_gzp_host.c nrf_gzp_host_nrf51.c
  group Device
    ../../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../../components/toolchain/: system_nrf51.c
