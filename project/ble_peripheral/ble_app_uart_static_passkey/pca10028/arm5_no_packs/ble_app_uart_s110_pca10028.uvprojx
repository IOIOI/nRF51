# Keil uVision project ble_app_uart_s110_pca10028.uvprojx, settings and files
target nrf51422_xxac_s110 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10028 S110 NRF51 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\..\..\bsp;..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\components\ble\common;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\components\libraries\button;..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\components\device;..\..\..\..\..\components\toolchain;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\libraries\gpiote;..\..\config;..\..\..\..\..\components\libraries\trace;..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\components\ble\device_manager
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../: main.c
  group Board Support
    ../../../../bsp/: bsp.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../components/ble/ble_services/ble_nus/: ble_nus.c
    ../../../../../components/ble/device_manager/: device_manager_peripheral.c
  group nRF_Drivers
    ../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c
    ../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../components/libraries/timer/: app_timer.c
    ../../../../../components/libraries/uart/: retarget.c
    ../../../../../components/libraries/trace/: app_trace.c
  group nRF_SoftDevice
    ../../../../../components/softdevice/s110/doc/: s110_nrf51_8.0.0_licence-agreement.txt
    ../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group ::Device
    RTE/Device/nRF51422_xxAC/: arm_startup_nrf51.s system_nrf51.c
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: s110_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD
  c misc: --c99
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 3.40.0, Device:Startup 7.1.0
